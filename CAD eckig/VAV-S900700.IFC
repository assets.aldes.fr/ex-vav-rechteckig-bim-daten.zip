Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\tmink\OneDrive - Vento\Bureaublad\a_EXHAUSTO\E_Konfigurationen\VAV-S900700.IFC
Time: 2025-05-08T12:10:02+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject (2)
Description: Default Project

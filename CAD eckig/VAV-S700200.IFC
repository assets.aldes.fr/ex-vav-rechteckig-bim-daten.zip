Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\tmink\OneDrive - Vento\Bureaublad\a_EXHAUSTO\E_Konfigurationen\VAV-S700200.IFC
Time: 2025-05-08T11:41:58+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project
